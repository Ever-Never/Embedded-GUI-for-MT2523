# IAR project coap.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; MTK_NVDM_ENABLE; PCFG_OS=2; _REENT_SMALL; MTK_SYS_TRNG_ENABLE; MTK_MINISUPP_ENABLE; PRODUCT_VERSION=7697; MTK_FLASH_DIRECT_DL; MTK_PATCH_DL_ENABLE; MTK_BSPEXT_ENABLE; MTK_HAL_LOWPOWER_ENABLE; MBEDTLS_CONFIG_FILE=<config-mtk-basic.h>; MTK_EXTERNAL_FLASH_ENABLE; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,pe021
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\middleware\MTK\minisupp\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\driver\board\linkit7697_hdk\util\inc; inc; ..\inc; src\common\include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\linkit7697_hdk\external_flash\inc; driver\board\linkit7697_hdk\external_flash\driver\board\linkit7697_hdk\external_flash\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\linkit7697_hdk\ept\inc; ..\..\..\..\..\middleware\util\include; ..\..\..\..\..\middleware\MTK\minicli\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source; ..\..\..\..\..\driver\chip\mt7687\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\middleware\MTK\minisupp\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\MTK\wifi_stack\inc; inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc_core; ..\..\..\..\..\middleware\util\include; ..\..\..\..\..\middleware\MTK\minicli\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source; ..\..\..\..\..\middleware\mlog\include; ..\..\..\..\..\driver\chip\mt7697\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\util\include; ..\..\..\..\..\middleware\MTK\minicli\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source; ..\..\..\..\..\middleware\mlog\include; ..\..\..\..\..\driver\chip\mt7697\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\middleware\third_party\libcoap\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\third_party\lwip\src\include\netif; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\third_party\lwip\src\include\netif; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\project\linkit7697_hdk\apps\coap\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\middleware\third_party\libcoap; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\driver\board\linkit7697_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: coap.bin
  ILINK.IlinkOutputFile: coap.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: freertos_create_thread.out
  group driver/board
    ../../../../../driver/board/linkit7697_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/board/linkit7697_hdk/ept/src/: bsp_gpio_ept_config.c
  group driver/chip
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c
  group iarfs
    $EW_DIR$/arm/src/lib/: close.c lseek.c open.c read.c remove.c write.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c syslog.c syslog_cli.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7687/: port_tick.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_IAR.a
  group middleware/MTK/connsys
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_util.c uart_slim_version.c
  group middleware/MTK/dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group middleware/MTK/nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group middleware/MTK/wifi_service
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_cm4_scan.c wifi_repeater.c get_profile_string.c inband_queue_option.c misc.c wifi_os_api.c wifi_profile.c wifi_wps.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
  group middleware/third_party/libcoap
    ../../../../../middleware/third_party/libcoap/src/: async.c block.c coap_list.c debug.c encode.c hashkey.c net.c option.c pdu.c resource.c str.c subscribe.c uri.c
  group middleware/third_party/lwip
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
  group N9
    ../../../../../tools/iar/mt7687/N9/: mt76X7_n9_image.c
  group project/linkit7697_hdk/apps/coap
    ../src/: client.c ept_eint_var.c ept_gpio_var.c main.c regions_init.c server.c sys_init.c system_mt7687.c network_default_config.c wifi_lwip_helper.c
    ./: startup_mt7687.s
