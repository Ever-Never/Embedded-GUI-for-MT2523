<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\i2c_control_EEPROM_with_dma_ex.ewp</path>
  </project>
  <batchBuild/>
</workspace>


