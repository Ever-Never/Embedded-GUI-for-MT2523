<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\audio_play_1k_tone.ewp</path>
  </project>
  <batchBuild/>
</workspace>


