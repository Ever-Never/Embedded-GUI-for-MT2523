<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\accdet_detect_earphone_status.ewp</path>
  </project>
  <batchBuild/>
</workspace>


