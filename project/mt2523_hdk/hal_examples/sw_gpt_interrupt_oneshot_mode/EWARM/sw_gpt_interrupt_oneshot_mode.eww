<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\sw_gpt_interrupt_oneshot_mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


