<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ble_ancs_ios_notification.ewp</path>
  </project>
  <batchBuild/>
</workspace>


