<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gnss_get_location.ewp</path>
  </project>
  <batchBuild/>
</workspace>


