<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\\bt_spp_transfer_data.ewp</path>
  </project>
  <batchBuild/>
</workspace>


