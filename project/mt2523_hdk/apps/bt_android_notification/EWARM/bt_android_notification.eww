<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bt_android_notification.ewp</path>
  </project>
  <batchBuild/>
</workspace>


