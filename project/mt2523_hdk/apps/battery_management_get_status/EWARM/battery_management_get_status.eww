<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\battery_management_get_status.ewp</path>
  </project>
  <batchBuild/>
</workspace>


