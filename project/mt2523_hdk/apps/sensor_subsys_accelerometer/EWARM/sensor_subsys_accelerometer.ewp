# IAR project sensor_subsys_accelerometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_SENSOR_ACCELEROMETER_USE; MTK_SENSOR_ACCELEROMETER_USE_BMA255; MTK_CTP_ENABLE; BMA255_USE_POLLING=y
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\driver\board\component\common; ..\..\..\..\..\driver\board\component\lcm\ST7789H2; ..\inc\bt_audio; ..\inc\bt_audio\sink; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\inc\graphicLib; ..\..\..\..\..\middleware\MTK\atci\inc; ..\inc\gnss_screen; ..\inc\pxp_screen; ..\inc\sensor_demo; ..\inc\watch_face; ..\..\..\..\..\driver\board\mt25x3_hdk\lcd; ..\..\..\..\..\middleware\MTK\sensor_subsys\inc; ..\..\..\..\..\driver\board\component\mems\inc; ..\..\..\..\..\driver\board\component\mems\src\libyas533\inc; ..\..\..\..\..\middleware\MTK\gnss\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\backlight; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm\src\nvdm_internal.h; ..\..\..\..\..\middleware\MTK\nvdm\src\portable; ..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc; ..\..\..\..\..\middleware\MTK\gnss\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc; ..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137; ..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\driver\board\component\touch_panel\common\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\\gt9137; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\everlight; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate_variability\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc_core; ..\..\..\..\..\prebuilt\middleware\MTK\nvdm\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\mems_init; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: sensor_subsys_accelerometer.bin
  ILINK.IlinkOutputFile: sensor_subsys_accelerometer.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: ept_eint_var.c ept_gpio_var.c main.c regions_init.c sys_init.c
  group board
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/GCC/mt2523/: port_tick.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group kservice
    ../../../../../kernel/service/src/: os_port_callback.c
  group lib
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group mems
    ../../../../../driver/board/component/mems/src/: bma255_i2c_operation.c bma255_sensor_adaptor.c bma2x2.c bmi160.c mems_bus.c sensor_manager_driver.c
    ../../../../../driver/board/mt25x3_hdk/mems_init/: mems_init.c
  group sensor_subsys
    ../../../../../middleware/MTK/sensor_subsys/src/: sensor_manager.c
