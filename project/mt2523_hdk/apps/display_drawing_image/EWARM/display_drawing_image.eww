<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\display_drawing_image.ewp</path>
  </project>
  <batchBuild/>
</workspace>


