<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gdi_display_helloworld.ewp</path>
  </project>
  <batchBuild/>
</workspace>


