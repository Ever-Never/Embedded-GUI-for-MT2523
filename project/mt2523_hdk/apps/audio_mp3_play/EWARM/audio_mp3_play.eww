<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\audio_mp3_play.ewp</path>
  </project>
  <batchBuild/>
</workspace>


