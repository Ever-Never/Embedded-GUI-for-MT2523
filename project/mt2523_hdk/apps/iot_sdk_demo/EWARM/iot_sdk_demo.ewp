# IAR project iot_sdk_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_SENSOR_ACCELEROMETER_USE; MTK_SENSOR_ACCELEROMETER_USE_BMA255; MTK_SENSOR_BIO_USE; MTK_SENSOR_BIO_USE_MT2511; FUSION_HEART_RATE_MONITOR_USE=M_INHOUSE_HEART_RATE_MONITOR; FUSION_BLOOD_PRESSURE_USE=MI_INHOUSE_BLOOD_PRESSURE; SENSOR_FUSTION_TASK_ENABLED; SENSOR_DEMO; MTK_DEVELOPMENT_BOARD_HDK; MTK_CTP_ENABLE; configOVERRIDE_DEFAULT_TICK_CONFIGURATION; MTK_BT_AT_COMMAND_ENABLE; MTK_SMART_BATTERY_ENABLE; MTK_USB_DEMO_ENABLED; MTK_PORT_SERVICE_ENABLE; MTK_ATCI_VIA_PORT_SERVICE; __MTK_TARGET__; MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>; __BT_DEBUG__; MTK_NVDM_ENABLE; MTK_GNSS_ENABLE; MTK_OS_CPU_UTILIZATION_ENABLE; MTK_SYSTEM_AT_COMMAND_ENABLE; MT2511_USE_SPI; USE_EXTERNAL_BOOST
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\driver\board\component\common; ..\..\..\..\..\driver\board\component\lcm\ST7789H2; ..\inc\bt_audio; ..\inc\bt_audio\sink; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\atci\inc; ..\inc\gnss_screen; ..\inc\pxp_screen; ..\inc\sensor_demo; ..\inc\watch_face; ..\..\..\..\..\driver\board\mt25x3_hdk\lcd; ..\..\..\..\..\middleware\MTK\sensor_subsys\inc; ..\..\..\..\..\driver\board\component\mems\inc; ..\..\..\..\..\driver\board\component\mems\src\libyas533\inc; ..\..\..\..\..\middleware\MTK\gnss\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\backlight; ..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm\src\nvdm_internal.h; ..\..\..\..\..\middleware\MTK\nvdm\src\portable; ..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc; ..\..\..\..\..\middleware\MTK\gnss\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc; ..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137; ..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\driver\board\component\touch_panel\common\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\gt9137; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\it7258; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\config; ..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\everlight; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\blood_pressure\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc_core; ..\..\..\..\..\prebuilt\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\kiss_fft; ..\..\..\..\..\middleware\MTK\port_service\inc; ..\..\..\..\..\middleware\MTK\usb\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\middleware\third_party\kiss_fft; ..\..\..\..\..\middleware\MTK\bt_sink\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\inc\main_screen; ..\..\..\..\..\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\middleware\MTK\gdi\inc; ..\inc\hogp; ..\..\..\..\..\driver\board\mt25x3_hdk\mems_init; ..\..\..\..\..\middleware\MTK\bluetooth_service\inc; Z:\main_dev\gva\driver\board\mt25x3_hdk\msdc\inc; ..\..\..\..\..\middleware\MTK\audio\port\mt2523\inc; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: iot_sdk_demo.bin
  ILINK.IlinkOutputFile: iot_sdk_demo.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: ept_eint_var.c ept_gpio_var.c FontRes.c hci_log.c main.c regions_init.c sys_init.c task_def.c
  group at_cmd
    ../../../../../middleware/MTK/atci/at_command/: at_command.c at_command_audio.c at_command_audio_tuning.c at_command_backlight.c at_command_biogui.c at_command_bt.c at_command_bt_testbox.c at_command_calibration_capid.c at_command_camera.c at_command_charger.c at_command_clock.c at_command_crypto.c at_command_ctp.c at_command_ctp_simulate.c at_command_dvfs.c at_command_gnss.c at_command_gpio.c at_command_gsensor.c at_command_keypad.c at_command_keypad_simulate.c at_command_lcm.c at_command_led.c at_command_mem.c at_command_msdc.c at_command_nvdm.c at_command_pmu.c at_command_reg.c at_command_rtc.c at_command_sensor.c at_command_serial_port.c at_command_sleep_manager.c at_command_syslog.c at_command_system.c at_command_testframework.c at_command_vibrator.c at_command_wdt.c
    ../../../../../middleware/third_party/kiss_fft/: kiss_fft.c
  group atci
    ../../../../../middleware/MTK/atci/src/: atci_adapter.c atci_handler.c atci_main.c
  group battery
    ../src/: battery_message.c
  group battery_management_core
    ../../../../../middleware/MTK/battery_management/port/mt2523/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
  group bluetooth_service
    ../../../../../middleware/MTK/bluetooth_service/src/: bt_device_manager.c
  group board
    ../../../../../middleware/MTK/audio/src/: audio_dsp_fd216_db_to_gain_value_mapping_table.c
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt25x3_hdk/bt_codec/src/: bt_a2dp_codec.c bt_hfp_codec.c
    ../../../../../driver/board/component/touch_panel/ctp_goodix_gt9xxx/gt9137/: ctp_goodix_gt9xxx.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
    ../../../../../driver/board/component/lcm/ST7789H2/: lcd.c
    ../../../../../driver/board/component/lcm/RM69032/: lcd_RM69032.c
    ../../../../../driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/gt9137/: touch_panel_custom_goodix.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/it7258/: touch_panel_custom_ite.c
  group bt_audio
    ../../../../../middleware/MTK/audio/src/: audio_middleware_api.c
    ../../../../../middleware/MTK/audio/port/mt2523/src/: audio_nvdm.c
    ../src/bt_audio/: bt_audio.c
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
    ../src/: bt_init.c
    ../src/bt_audio/sink/: bt_sink_app_cmd.c bt_sink_app_event.c bt_sink_app_main.c bt_sink_app_mapping_table.c
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bt_sink
    ../../../../../middleware/MTK/bt_sink/src/: bt_sink_srv.c bt_sink_srv_a2dp.c bt_sink_srv_action.c bt_sink_srv_am_med_mgr.c bt_sink_srv_am_task.c bt_sink_srv_ami.c bt_sink_srv_atci_cmd.c bt_sink_srv_audio_setting.c bt_sink_srv_audio_tunning.c bt_sink_srv_avrcp.c bt_sink_srv_common.c bt_sink_srv_conmgr.c bt_sink_srv_custom_db.c bt_sink_srv_db.c bt_sink_srv_hf.c bt_sink_srv_hf_call_manager.c bt_sink_srv_hf_multipoint.c bt_sink_srv_music.c bt_sink_srv_pbapc.c bt_sink_srv_spp.c bt_sink_srv_state_notify.c bt_sink_srv_utils.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group gdi
    ../../../../../middleware/MTK/gdi/src/: gd_primitive.c gd_primitive16.c gd_primitive24.c gd_primitive32.c gd_primitive8.c gdi.c gdi_common_language.c gdi_font_engine.c gdi_font_show_char.c gdi_image.c gdi_image_bmp.c gdi_imgdec_bmp.c gdi_imgdec_bytestream.c gdi_imgdec_resizer.c gdi_language_module.c gdi_layer.c gdi_lcd.c gdi_mutex.c gdi_primitive.c gdi_resource.c gdi_resource_weak_symbol.c
  group gnss_screen
    ../src/gnss_screen/: epo_demo.c gnss_app.c gnss_demo_screen.c gnss_ring_buffer.c gnss_timer.c
    ../../../../../middleware/MTK/gnss/src/: gnss_api.c gnss_driver.c
  group hogp
    ../src/hogp/: ble_hogp.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c os_port_callback.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/GCC/mt2523/: port_tick.c
  group lib
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_a2dp_iar.a libbt_avrcp_enhance_iar.a libbt_avrcp_iar.a libbt_driver_2523_iar.a libbt_hfp_iar.a libbt_iar.a libbt_pbapc_iar.a libbt_spp_iar.a
    ../../../../../prebuilt/driver/board/component/bt_codec/lib/arm_cm4/: libcvsd_codec_CM4_IAR.a libmsbc_codec_CM4_IAR.a libplc_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge_IAR.a
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
    ../src/low_power_demo/: sleep_at_cmd.c
  group low_power_demo
    ../src/low_power_demo/: bt_at_cmd.c gnss_at_cmd.c
  group main_screen
    ../src/main_screen/: main_screen.c ui_demo_task.c
  group mems
    ../../../../../driver/board/component/mems/src/: bma255_i2c_operation.c bma255_sensor_adaptor.c bma2x2.c mems_bus.c sensor_manager_driver.c
    ../../../../../driver/board/mt25x3_hdk/mems_init/: mems_init.c
    ../../../../../driver/board/component/biosensor/mt2511/src/: vsm_driver.c vsm_i2c_operation.c vsm_platform_function.c vsm_sensor_subsys_adaptor.c vsm_spi_operation.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group port_service
    ../../../../../middleware/MTK/port_service/src/: serial_port.c serial_port_para.c serial_port_uart.c serial_port_usb.c
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_adap.c usbacm_drv.c
  group pxp_screen
    ../src/pxp_screen/: ble_gatt_common.c ble_gatt_connect.c ble_gatt_service.c ble_gatt_srv.c ble_gatt_utils.c ble_lls.c ble_pxp_app.c ble_pxp_main.c
  group sensor
    ../src/sensor_demo/: sensor_demo.c sensor_demo_screen.c
  group sensor_fusion
    ../../../../../middleware/MTK/sensor_subsys/src/algo_adaptor/: algo_adaptor.c blood_pressure_monitor_adaptor.c heart_rate_monitor_adaptor.c
    ../../../../../prebuilt/middleware/MTK/fusion_algo/blood_pressure/lib_core/: libbp_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/common/lib_core/: libcomm_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/heart_rate/lib_core/: libhr_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/lib_core/: libppgctrl_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/module/default/: ppg_control_module.c
  group sensor_subsys
    ../../../../../middleware/MTK/sensor_subsys/src/: sensor_manager.c
  group third_party
    ../../../../../middleware/third_party/mbedtls/library/: aes.c md5.c
  group ver_no
    ../../../../../middleware/MTK/verno/: verno.c
  group watch_face
    ../src/watch_face/: watch_face_app.c wf_image.c
