<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\no_rtos_initialize_system.ewp</path>
  </project>
  <batchBuild/>
</workspace>


