<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ept_configure_pins_by_ept.ewp</path>
  </project>
  <batchBuild/>
</workspace>