<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\irtx_send_pwd_data.ewp</path>
  </project>
  <batchBuild/>
</workspace>


