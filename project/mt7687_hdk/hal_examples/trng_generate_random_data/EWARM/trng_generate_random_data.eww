<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\trng_generate_random_data.ewp</path>
  </project>
  <batchBuild/>
</workspace>


