<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_slave_from_master.ewp</path>
  </project>
  <batchBuild/>
</workspace>


