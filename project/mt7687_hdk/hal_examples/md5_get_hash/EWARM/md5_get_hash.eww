<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\md5_get_hash.ewp</path>
  </project>
  <batchBuild/>
</workspace>


