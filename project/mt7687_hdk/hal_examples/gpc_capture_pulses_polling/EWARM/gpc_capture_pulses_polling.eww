<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\\gpc_capture_pulses_polling.ewp</path>
  </project>
  <batchBuild/>
</workspace>


