<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gdma_transfer_data_interrupt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


