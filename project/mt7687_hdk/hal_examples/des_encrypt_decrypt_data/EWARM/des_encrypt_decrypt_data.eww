<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\des_encrypt_decrypt_data.ewp</path>
  </project>
  <batchBuild/>
</workspace>


