<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\flash_read_write_data.ewp</path>
  </project>
  <batchBuild/>
</workspace>


